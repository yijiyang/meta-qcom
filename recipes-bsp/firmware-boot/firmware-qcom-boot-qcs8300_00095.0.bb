require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "463ffd7f20d243a5673ac49d744c8a35a3ab2067c3588be2741c2e6551f5a8f5"
