require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "c201c9e966a706c9e76685ff4298f0940958c4d4877299eee1248ef26b809aa0"
