require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "9c100d7b184ecf0ab9c4be71a8bb7c243fdc79a64380ca3025024dd2b14c5078"
