require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "4500b904d8195e89dd59c0d196e934b88c4737c57b5be20c60f156b8b73e9ddb"
