PACKAGECONFIG:append:qcom = " tests fastcv"
